Commit message: IRL 1 Demo is working robustly now

File: PM_model.urdf (robot description, URDF)
Before this commit: robot pointmass, 4 links, 3 joints
Links:
- link x_axis: mass 0 -> 0.00001
- link y_axis: mass 0 -> 0.00001
